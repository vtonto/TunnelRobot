# Keil uVision project TunnelRobot.uvprojx, settings and files
target TunnelRobot (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TunnelRobot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\FWlib\inc;..\Libraries\CMSIS;..\User;..\User\MOTOR;..\User\DELAY;..\User\SYS;..\User\SERVO;..\User\ADC;..\User\USART;..\User\DMA;..\User\LIGHT;..\User\IIC;..\User\USART-IIC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/FWlib/src/: misc.c stm32f10x_crc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_usart.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/MOTOR/: motor.c
    ../User/DELAY/: delay.c
    ../User/SYS/: sys.c
    ../User/ADC/: bsp_adc.c
    ../User/SERVO/: servo.c
    ../User/DMA/: dma_uart.c
    ../User/LIGHT/: light.c
    ../User/USART-IIC/: IOI2C.c UART2.c
